# Keil uVision project LTC6946_v0_1.uvprojx, settings and files
target LTC6946_v0_1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F051K4Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LTC6946_v0_1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Application/User
    ../Src/: spi.c stm32f0xx_hal_msp.c dac.c usart.c main.c stm32f0xx_it.c gpio.c LT_SPI.c LTC6946.c MC_DAT_15R5A.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c_ex.c
software components: CMSIS:CORE 4.3.0
